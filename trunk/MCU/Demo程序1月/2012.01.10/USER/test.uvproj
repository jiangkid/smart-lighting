# Keil uVision project test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test +hex
  c flags: Optim=1
  c include: ..\USER;..\SYSTEM;..\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: STM32F10x.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/: delay.c sys.c usart.c
  group HARDWARE
    ../HARDWARE/: 12864.c checkdisp.c checkfunc.c disp.c eeprom.c func.c gprs.c key.c rtc.c setdisp.c setfunc.c timer.c usartx.c beep.c led.c zigbeefunc.c gprsfunc.c
